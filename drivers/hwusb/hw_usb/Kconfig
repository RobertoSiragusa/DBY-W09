## drivers/hwusb/hw_usb/Kconfig
```kconfig
#
# huawei usb drivers
#

config HUAWEI_USB_HW
	bool "huawei usb"
	default n
	help
	  Say Y here to enable usb driver.
```
